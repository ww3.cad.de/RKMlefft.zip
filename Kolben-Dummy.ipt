# Autodesk Inventor part: Kolben-Dummy
## iProperties
Created: 2008-07
Part Number: Kolben-Dummy
Document SubType Name: Modeling
Designer: WH
Density: 1 g/cm^3
Author: WH
## Feature names
1. Basis1

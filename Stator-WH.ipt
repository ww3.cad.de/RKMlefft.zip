# Autodesk Inventor part: Stator-WH
## iProperties
Created: 2008-07
Part Number: Stator-WH
Document SubType Name: Modeling
Designer: WH
Density: 1 g/cm^3
Author: WH
## Feature names
1. Basis1
